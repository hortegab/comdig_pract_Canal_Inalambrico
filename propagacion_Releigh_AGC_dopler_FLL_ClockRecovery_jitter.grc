options:
  parameters:
    author: Example
    category: Custom
    description: Adjust the noise and constellation... see what happens!
    generate_options: qt_gui
    id: ber_simulation
    output_language: python
    run: run_stop
    title: BER Simulation
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: (Rs/2)*(1+Rolloff)
  states: {}
- name: Bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Constelacion
  id: variable
  parameters:
    value: MiconstellationObject.points()
  states: {}
- name: M
  id: variable
  parameters:
    value: len(Constelacion)
  states: {}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: digital.constellation_qpsk().points()
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: (0,1,2,3)
    type: calcdist
  states: {}
- name: NbpS
  id: variable
  parameters:
    value: '8'
  states: {}
- name: NnivelesQ
  id: variable
  parameters:
    value: int(math.pow(2,NbpS))
  states: {}
- name: Ph_correction
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: PLL Phase
    orient: Qt.Horizontal
    start: '-numpy.pi'
    step: 2*numpy.pi/720.
    stop: numpy.pi
    value: numpy.pi/4.
  states: {}
- name: Rb
  id: variable
  parameters:
    value: NbpS*samp_rate_audio
  states: {}
- name: Retardo_Timing
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Timing
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '0'
  states: {}
- name: Retardo_propag
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Propagation delay compensation
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*200
    value: int(ntaps/Sps)+1
  states: {}
- name: Rolloff
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/Bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: int(math.floor(samp_rate_to_usrp/Rs))
  states: {}
- name: T_observacion_potencia
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: TimeAligment
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: TimeAligment
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*20
    value: '2'
  states: {}
- name: Vp
  id: variable
  parameters:
    value: '1.'
  states: {}
- name: h_rrc
  id: variable
  parameters:
    value: wform.rrcos(Sps,ntaps,Rolloff)
  states: {}
- name: mapdirect
  id: variable
  parameters:
    value: coding.direct_map(Constelacion)
  states: {}
- name: mapinverse
  id: variable
  parameters:
    value: coding.inverse_map(Constelacion)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Pause
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(Rs*Sps)
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '11000'
  states: {}
- name: samp_rate_to_usrp
  id: variable
  parameters:
    value: int(samp_rate_usrp_rx/512)
  states: {}
- name: samp_rate_usrp_rx
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: E3TRadio_mean_meter_0
  id: E3TRadio_mean_meter
  parameters:
    reset: '1'
  states: {}
- name: Tx_1_0_0
  id: virtual_sink
  parameters:
    stream_id: T7
  states: {}
- name: Tx_1_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R7
  states: {}
- name: Tx_1_0_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: R3
  states: {}
- name: Tx_1_0_0_2
  id: virtual_sink
  parameters:
    stream_id: T4
  states: {}
- name: Tx_1_0_0_2_0
  id: virtual_sink
  parameters:
    stream_id: R4
  states: {}
- name: Tx_1_0_0_2_0_0
  id: virtual_sink
  parameters:
    stream_id: T3
  states: {}
- name: Tx_1_0_0_2_0_1
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {}
- name: b_Canal_simple_cc_0
  id: b_Canal_simple_cc
  parameters:
    Ch_Loss_dB: '0'
    Ch_NodB: '-70'
    Ch_Phoffset: '0.'
    Ch_Toffset: '2'
    Fluctuacion: '40'
    Foffset: '0.'
    N_fluct: Sps*6
    samp_rate: samp_rate_to_usrp
  states: {}
- name: b_FLL_tunner_0
  id: b_FLL_tunner
  parameters:
    ConstellationObject: MiconstellationObject
  states: {}
- name: b_PSD_c_0
  id: b_PSD_c
  parameters:
    Ensayos: '1000000'
    Fc: '0'
    N: '1024'
    Ymax: '1e-5'
    gui_hint: menu@2:2,0,1,1
    samp_rate_audio: samp_rate
  states: {state: disabled}
- name: b_cdf_ff_0
  id: b_cdf_ff
  parameters:
    EjeX: '''potencia'''
    Xmax: '4.'
    Xmin: '-4.'
    gui_hint: menu@4:0,0,1,1
  states: {state: disabled}
- name: b_pdf_cdf_ff_0
  id: b_pdf_cdf_ff
  parameters:
    EjeX: '''Potencia (dB)'''
    Xmax: '1.'
    Xmin: '-6.'
    gui_hint: menu@4:0,0,1,2
    pdf_max: '1.33'
  states: {state: disabled}
- name: b_pdf_ff_0
  id: b_pdf_ff
  parameters:
    EjeX: '''potencia'''
    Xmax: '-1.'
    Xmin: '-8.'
    gui_hint: menu@4:0,0,1,1
    pdf_max: '0.7'
  states: {state: disabled}
- name: b_quantizer_fb_0
  id: b_quantizer_fb
  parameters:
    NivelesQ: NnivelesQ
    Vmax: Vp
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: TimeAligment
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Vp/(NnivelesQ/2)/2
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.1'
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/hortegab/MisGits/comdig_pract_Canal_Inalambrico/bush-clinton_debate_waffle.wav
    repeat: 'True'
  states: {}
- name: coding
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy\nimport math\n#######################################################\n##        Done by Homero Ortega Boada              ##\n##        comdiguis@saber.uis.edu.co                 ##\n##     Universidad Industrial de Santander           ##\n#######################################################\n#######################################################\n##       Constellation map  identification           ##\n#######################################################                  \n# Constellation points are analyzed to determine the \n# the map used for ordering of the constellation points\ndef sum_modulus(a,b,modulus):\n    # realiza una suma de a y b en modulo modulus\n    return (a+b)%modulus\n\ndef angle_map(constellation_points):\n    # esta funcion entrega todos los angulos positivos entre 0 y 2pi\n    angles=numpy.angle(constellation_points)\n    return sum_modulus(angles, 2*math.pi, 2*math.pi)\n\ndef inverse_map(constellation_points):\n    M=len(constellation_points)\n    angles=angle_map(constellation_points)\n    angles=sum_modulus(angles,-angles[0], 2*math.pi) # giro a agulo cero\n    delta_angle= 2*math.pi/M     # angulo entre puntos\n    cod_inv=numpy.round(angles/delta_angle)\n    cod_inv=cod_inv.astype(numpy.int) #conversion a entero \n    return cod_inv\n\ndef direct_map(constellation_points):\n    M=len(constellation_points)\n    codinv=inverse_map(constellation_points)\n    coddirect=numpy.array([0]*M)\n    for j in range(M):\n        temp=numpy.where(codinv==j)\n        coddirect[j]=temp[0][0]\n    return coddirect\n\n\"\"\" # SECCION DE PRUEBAS DEL CODIGO\nimport gnuradio.digital as digital\nconstelacion=digital.constellation_8psk().points()\nprint(\"constelacion = \", constelacion)\nmapdirect=direct_map(constelacion)\nprint(\"codigo directo = \", mapdirect)\nmapinverse=inverse_map(constelacion)\nprint(\"codigo inverso = \", mapinverse)\n\"\"\"\n\n\n\n\n\n\n"
  states: {}
- name: digital_chunks_to_symbols_xx
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: MiconstellationObject.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: M
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: M
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: mapdirect
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: mapinverse
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*math.pi/100.0
    max_dev: '1.5'
    osps: '1'
    sps: Sps
    taps: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(Sps), Rolloff, ntaps*nfilts)
    type: ccf
  states: {}
- name: e1_0_0_0_1_0_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: R0
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: interp_fir_filter_xxx_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h_rrc
    type: ccc
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,4
    label0: Constelation Timing
    label1: Senal MPAM
    label2: PSD en R1a
    label3: Potencia Recibida
    label4: histograma, PDF, CDF
    num_tabs: '5'
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: CAPA Adaptacion
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: CAPA APLICACION
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: CAPA COD DIF
  states: {}
- name: note_0_0_0_0_1
  id: note
  parameters:
    note: CAPA MAP
  states: {}
- name: note_0_0_0_1
  id: note
  parameters:
    note: CAPA Modulation
  states: {}
- name: note_0_0_0_2
  id: note
  parameters:
    note: CAPA M-PAM
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: menu@0:1,0,1,1
    label1: T4
    label2: R4
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: menu@3:0,1,1,1
    label1: Pr(dB) Instantanea
    max: '0'
    min: '-9'
    type: float
    unit1: dB
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: menu@3:0,0,1,1
    label1: Pr(dB) promediada
    max: '0'
    min: '-9'
    type: float
    unit1: dB
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: menu@3:1,0,1,2
    label1: ''
    name: '"Power signal"'
    size: int(samp_rate*T_observacion_potencia)
    srate: samp_rate
    type: float
    ylabel: Nivel de RF (dB)
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_to_usrp
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate_to_usrp
    interp: samp_rate
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: R2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: T2
  states: {}
- name: vs_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R1
  states: {}
- name: vs_0_2
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: vs_0_2_0
  id: virtual_sink
  parameters:
    stream_id: T0
  states: {}
- name: vs_0_2_0_0
  id: virtual_sink
  parameters:
    stream_id: R0
  states: {}
- name: vs_0_2_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R0a
  states: {}
- name: vso_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: T1
  states: {}
- name: vso_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R1
  states: {}
- name: vso_0_1_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: R1a
  states: {state: disabled}
- name: wform
  id: epy_module
  parameters:
    source_code: |
      import math
      import numpy
      #######################################################
      ##        Hecho por Homero Ortega Boada              ##
      ##        comdiguis@saber.uis.edu.co                 ##
      ##     Universidad Industrial de Santander           ##
      #######################################################

      #######################################################
      ##               Forma rectangular                   ##
      #######################################################                       
      def rect(Sps,ntaps):
          h=ntaps*[0,]
          for n in range(Sps):
              k=int(ntaps/2) # esto es para que h[n] quede centrada en la mitad del vector
              h[k-n]=1.
          return h

      #######################################################
      ##               Forma de Nyquist                    ##
      #######################################################                       
      def nyq(Sps,ntaps):
          ntaps_min=-int(ntaps/2)
          ntaps_max=abs(ntaps_min)-1+int(math.ceil(ntaps/2.-abs(ntaps_min)))
          h=ntaps*[0,]
          for n in range(ntaps):
              k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
              h[n]=numpy.sinc(k/Sps)
          Amp=numpy.amax(h)
          return h/Amp

      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=numpy.amax(h)
          return h/Amp

      #######################################################
      ##            Forma Raiz de Coseno Alzado            ##
      #######################################################                       

      def rrcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              beta4=4.*beta
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if k==0:
                      h[n]=1+beta*(4./math.pi-1.)
                  elif abs(k)==Sps/beta4:
                      ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                      hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                      h[n]=(ha+hb)*beta/math.sqrt(2.)
                  else:
                      ks=k/Sps
                      kspi=math.pi*ks
                      Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                      Den=kspi*(1.-(beta4*ks)**2)
                      h[n]=Num/Den                
          Amp=numpy.amax(h)
          return h/Amp
  states: {}

connections:
- [E3TRadio_mean_meter_0, '0', blocks_nlog10_ff_0_0, '0']
- [analog_agc2_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [b_Canal_simple_cc_0, '0', analog_agc2_xx_0, '0']
- [b_Canal_simple_cc_0, '0', vs_0_2_0_0, '0']
- [b_FLL_tunner_0, '0', digital_constellation_decoder_cb_0, '0']
- [b_FLL_tunner_0, '0', vs_0_0_1, '0']
- [b_quantizer_fb_0, '0', Tx_1_0_0, '0']
- [b_quantizer_fb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_1, '0', E3TRadio_mean_meter_0, '0']
- [blocks_multiply_xx_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', b_cdf_ff_0, '0']
- [blocks_nlog10_ff_0, '0', b_pdf_cdf_ff_0, '0']
- [blocks_nlog10_ff_0, '0', b_pdf_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', Tx_1_0_0_2, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_unpacked_to_packed_xx_0, '0', Tx_1_0_0_1, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_wavfile_source_0, '0', b_quantizer_fb_0, '0']
- [digital_chunks_to_symbols_xx, '0', interp_fir_filter_xxx_0_0_0, '0']
- [digital_chunks_to_symbols_xx, '0', vs_0_2, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_0_0_0_0, '0']
- [digital_diff_decoder_bb_0, '0', Tx_1_0_0_2_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_delay_0_0_0, '0']
- [digital_diff_encoder_bb_0, '0', Tx_1_0_0_2_0_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', Tx_1_0_0_2_0_1, '0']
- [digital_map_bb_0_0, '0', Tx_1_0_0_1_0_0, '0']
- [digital_map_bb_0_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', b_FLL_tunner_0, '0']
- [e1_0_0_0_1_0_0_0_0_1_0_0, '0', blocks_rms_xx_0, '0']
- [interp_fir_filter_xxx_0_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', b_Canal_simple_cc_0, '0']
- [rational_resampler_xxx_0, '0', vs_0_2_0, '0']
- [rational_resampler_xxx_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [rational_resampler_xxx_0_0, '0', vs_0_2_0_0_0, '0']
- [virtual_source_0, '0', digital_map_bb_0_0, '0']
- [virtual_source_0_0, '0', digital_chunks_to_symbols_xx, '0']
- [vso_0_1_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [vso_0_1_0_0_0_0, '0', qtgui_const_sink_x_0, '1']
- [vso_0_1_0_0_1_0_0, '0', b_PSD_c_0, '0']

metadata:
  file_format: 1
